# Keil uVision project boot_ram.uvprojx, settings and files
target boot_ram_ln882x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: boot_ram
  AfterMake: python ..\..\..\..\tools\user_cmd\after_build_soc.py @L
  AfterMake: ..\..\..\..\tools\bin\mkimage.exe cmd_boot @L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LN882x BOOTRAM_OSAL __FILE__=NULL TDEFL_LESS_MEMORY MINIZ_NO_ARCHIVE_APIS MINIZ_NO_STDIO MINIZ_NO_TIME
  c include: ..\..\..\..\mcu\ln88xx;..\..\..\..\mcu\CMSIS_5.3.0;..\..\..\..\mcu\driver_ln882x\inc;..\..\..\..\mcu\driver_ln882x\inc\reg;..\..\..\..\components;..\..\..\..\components\serial;..\..\..\..\components\fs\partition_mgr;..\..\..\..\components\fota\ota_agent;..\..\..\..\components\fs\kv\kv_port;..\..\..\..\components\fs\kv\kv;..\bsp;..\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\bootram_ln882x.sct
  group driver_hal
    ../../../../mcu/driver_ln882x/src/hal/: cache.c flash.c hal_common.c hal_dma.c hal_syscon.c qspi.c hal_uart.c hal_sleep.c hal_efuse.c
  group cpu
    ../startup/: startup_ln882x.S
    ../../../../mcu/ln88xx/: system_ln88xx.c
  group boot
    ../main/: main.c cmd_mode.c file_mode.c mode_ctrl.c ramcode_header.c ramcode_port.c ymodem.c
    ../../../../lib/: drv_ll_ln882x.lib
  group utils
    ../../../../components/utils/: crc32.c crc16.c wrap_stdio.c
    ../../../../components/utils/runtime/: runtime.c
    ../bsp/: serial_hw.c
    ../../../../components/serial/: serial.c
    ../../../../components/utils/fifo/: fifobuf.c
    ../../../../components/utils/debug/: art_assert.c log.c
    ../../../../../../libraries/miniz/: miniz.c miniz_tdef.c miniz_tinfl.c
