# Keil uVision project boot_ln882x.uvprojx, settings and files
target boot_ram_ln882h (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: boot_ln882x
  AfterMake: python3  ..\..\..\..\tools\python_scripts\after_build_for_boot.py  --keilproj  #P  --output  boot_ln882x.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LN882x __FILE__
  c include: ..\..\..\..\mcu\ln88xx;..\..\..\..\mcu\CMSIS_5.3.0;..\..\..\..\mcu\driver_ln882x\inc;..\..\..\..\mcu\driver_ln882x\inc\reg;..\..\..\..\components;..\..\..\..\components\serial;..\..\..\..\components\fs\partition_mgr;..\..\..\..\components\fota\ota_agent;..\..\..\..\components\fs\nvds;..\bsp;..\main;..\cfg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\bootram_ln882x.sct
  group bsp
    ../bsp/: serial_hw.c boot_header.c
  group cpu
    ../startup/: startup_ln882x.S
    ../../../../mcu/ln88xx/: system_ln88xx.c
  group serial
    ../../../../components/serial/: serial.c
  group utils
    ../../../../components/utils/: crc32.c crc16.c wrap_stdio.c
    ../../../../components/utils/fifo/: fifobuf.c
    ../../../../components/utils/debug/: log.c
    ../../../../components/utils/reboot_trace/: reboot_trace.c
  group boot
    ../main/: main.c
  group ota_agent
    ../../../../components/fota/ota_agent/: ota_agent.c ota_image.c ota_port.c xz_decompress.c
  group fs
    ../../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../../components/fs/nvds/: ln_nvds.c
  group driver_hal
    ../../../../mcu/driver_ln882x/src/hal/: cache.c flash.c hal_common.c hal_dma.c hal_gpio.c hal_syscon.c hal_timer.c hal_uart.c qspi.c hal_wdt.c
    ../../../../lib/: drv_ll_ln882x.lib
    ../../../../mcu/driver_ln882x/src/ll/: ll_gpio.c
